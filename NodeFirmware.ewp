# IAR project NodeFirmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030K6 ST STM32F030K6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030; FLASH_32K; FLASH_PAGE_1K; SENSOR_SHT30; USE_STDPERIPH_DRIVER
  ICCARM.PreInclude: Platform\types.h
  ICCARM.CCIncludePath2: ; Service\Timer; Service\Parameters; Service\Device; Service\ota; Platform; STM32F0xx_HAL_Driver\inc; Hardware\Flash; Hardware\System; Hardware\UART; Hardware\watchdog; Hardware\i2c; CMSIS; CMSIS\Include; STM32F0xx_StdPeriph_Driver\inc; Driver\led-segment; Driver\debug-led; Driver\alarm; Driver\sensor; Driver\stwd100; Driver\rf; apps
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NodeFirmware.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: CMSIS\stm32f030x6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_F091 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  ICCARM.CCDefines: DEBUG; STM32F091; HIGHFLASH_256; FLASH_PAGE_2K; SENSOR_SHT30; USE_STDPERIPH_DRIVER; INTERRUPT_VECTOR_RAM
  ICCARM.CCIncludePath2: ; Service\Timer; Service\Parameters; Service\Device; Service\ota; Platform; STM32F0xx_HAL_Driver\inc; Hardware\Flash; Hardware\System; Hardware\UART; Hardware\watchdog; Hardware\i2c; CMSIS; CMSIS\Include; STM32F0xx_StdPeriph_Driver\inc; Driver\led-segment; Driver\debug-led; Driver\alarm; Driver\rf; Driver\sensor; Driver\stwd100; apps
  OBJCOPY.OOCOutputFile: NodeFirmware.srec
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: NodeFirmware.srec
  ILINK.IlinkKeepSymbols: BOOT
  ILINK.IlinkIcfFile: CMSIS\stm32f030x6_image.icf
configuration Release_F091 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  ICCARM.CCDefines: STM32F091; HIGHFLASH_256; FLASH_PAGE_2K; SENSOR_HTS221; USE_STDPERIPH_DRIVER; INTERRUPT_VECTOR_RAM; RELEASE
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: NodeFirmware_F091.bin
  ILINK.IlinkKeepSymbols: BOOTLOADER
  ILINK.IlinkIcfFile: D:\Firmware zone\FactoryProject\Firmware\CMSIS\stm32f091xC_image.icf
configuration Image_F091 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  ICCARM.CCDefines: STM32F091; HIGHFLASH_256; FLASH_PAGE_2K; SENSOR_SHT30; USE_STDPERIPH_DRIVER; INTERRUPT_VECTOR_RAM; RELEASE
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: NodeFirmware_F091.bin
  ILINK.IlinkIcfFile: CMSIS\stm32f091xC_image.icf
configuration Image (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: NodeFirmware_F030.bin
  ILINK.IlinkIcfFile: CMSIS\stm32f030x6_image.icf
  group (top)
    ./: main.c stm32f0xx_conf.h
  group apps
    apps/: device-desc.h device-parameter.c device-parameter.h device-registers.c device-registers.h measure.c measure.h
  group CMSIS
    CMSIS/: startup_stm32f030x6.s startup_stm32f091.s stm32f030x6.icf stm32f030x6_image.icf stm32f091xC.icf stm32f091xC_image.icf stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group Driver/alarm
    Driver/alarm/: alarm.c alarm.h
  group Driver/debug-led
    Driver/debug-led/: debug-led.c debug-led.h
  group Driver/led-segment
    Driver/led-segment/: led-segment.c led-segment.h
  group Driver/rf
    Driver/rf/: e32xxx.c e32xxx.h
  group Driver/sensor
    Driver/sensor/: hts221.c hts221.h sensor.h sht30.c sht30.h
  group Driver/stwd100
    Driver/stwd100/: stwd100.c stwd100.h
  group Hardware/Flash
    Hardware/Flash/: flash.c flash.h
  group Hardware/i2c
    Hardware/i2c/: i2c.c i2c.h i2c_hal.c i2c_hal.h
  group Hardware/System
    Hardware/System/: system.c system.h
  group Hardware/UART
    Hardware/UART/: uart.c uart.h
  group Hardware/Watchdog
    Hardware/WatchDog/: watchdog.c watchdog.h
  group Platform
    Platform/: types.h
  group Service/Device
    Service/Device/: device.c device.h devicedef.h
  group Service/ota
    Service/ota/: ota.c ota.h
  group Service/Parameters
    Service/Parameters/: parameter.c parameter.h
  group Service/Timer
    Service/Timer/: timer.c timer.h
  group STM32F0xx_StdPeriph_Driver/inc
    STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group STM32F0xx_StdPeriph_Driver/src
    STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
